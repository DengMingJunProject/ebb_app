# Keil uVision project ebb_app.uvprojx, settings and files
target RELEASE (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F415VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ebb_app
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F4xx,HSE_VALUE=8000000,USE_HAL_DRIVER,STM32F415xx,HSE_VALUE=8000000,RCC_OSCILLATORTYPE=RCC_OSCILLATORTYPE_HSE,RCC_PLLSOURCE=RCC_PLLSOURCE_HSE,RCC_PLLM=4,RCC_PLLN=168,RCC_PLLP=2,RCC_PLLQ=4,__DEBUG_VERSION__
  c include: .\RTE\CMSIS_Driver;.\user\STM32_LIBRARIES;.\user;.\user\segger_rtt;.\user\Middlewares\crc;.\user\Middlewares\freertos_cli;.\user\Middlewares\xmodem
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./user/src/: beep.c button.c comm.c config.c crypt.c daemon.c election.c dwt.c event_log.c freertos_malloc.c main.c hash.c ioc.c rf_module.c rng.c secure_storage.c stm32f4xx_isr.c urg.c usb_host.c wdg.c usart.c ring_buffer.c pm.c macro_def.c
  group tm_lib
    ./libraries/STM32_LIBRARIES/: tm_stm32_rcc.c tm_stm32_nrf24l01.c tm_stm32_spi.c tm_stm32_gpio.c tm_stm32_exti.c tm_stm32_rtc.c
  group segger_rtt
    ./libraries/segger_rtt/: dbg.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group crc
    ./libraries/crc/: crc8.c crc16.c crc32.c
  group freertos_CLI
    ./libraries/freertos_cli/: FreeRTOS_CLI.c Sample-CLI-commands.c
    ./user/src/: console_user.c console_uart.c console_run_time.c
  group xmodem
    ./libraries/xmodem/: xmodem.c
  group lcm
    ./user/src/: mcp4018t.c lcdxx.c tca9535pwr.c
  group storage
    ./user/src/: lefs.c nand_membus.c fs.c devfs.c
  group smartcard
    ./user/src/: ltc1955.c smartcard.c
  group WinUSB
    ./user/src/: USBD_User_CustomClass_0.c WinUSB_Echo.c
  group UI
    ./user/src/: menu_func.c display.c
  group cm_backtrace
    ./libraries/cm_backtrace/: cm_backtrace.c
    ./libraries/cm_backtrace/fault_handler/keil/: cmb_fault.S
  group cjson
    ./libraries/cjson/: cJSON.c
  group MessageStorage
    ./user/src/: USBH_MSC.c MessageStorage.c
target DEBUG (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F415VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: as above
  output: ebb_app
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: as above
  c include: .\RTE\CMSIS_Driver;.\user;.\user\segger_rtt;.\libraries\xmodem;.\user\inc;.\libraries\STM32_LIBRARIES;.\libraries\segger_rtt;.\libraries\freertos_cli;.\libraries\crc;.\libraries\cm_backtrace;.\libraries\cjson
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: RTOS:Config 10.2.1, RTOS:Core 10.2.1, RTOS:Event Groups 10.2.1, RTOS:Heap 10.2.1, RTOS:Timers 10.2.1, CMSIS Driver:NAND:Custom 2.3.0, CMSIS:CORE 5.3.0, CMSIS:RTOS:FreeRTOS 10.2.1, CMSIS:RTOS2:FreeRTOS 10.2.1, Compiler:Event Recorder 1.4.0, Compiler:I/O:File 1.2.0, File System:CORE 6.13.0, File System:Drive:Memory Card 6.13.0, File System:Drive:NAND 6.13.0, USB:CORE 6.13.7, USB:Device 6.13.7, USB:Device:Custom Class 6.13.7, USB:Host 6.13.7, USB:Host:HID 6.13.7, CMSIS Driver:I2C 2.8, CMSIS Driver:MCI 2.8, CMSIS Driver:USB Device:Full-speed 2.19, CMSIS Driver:USB Host:Full-speed 2.21, Device:STM32Cube Framework:Classic 1.7.4, Device:STM32Cube HAL:CRYP 1.7.4, Device:STM32Cube HAL:Common 1.7.4, Device:STM32Cube HAL:Cortex 1.7.4, Device:STM32Cube HAL:DMA 1.7.4, Device:STM32Cube HAL:Flash 1.7.4, Device:STM32Cube HAL:GPIO 1.7.4, Device:STM32Cube HAL:HASH 1.7.4, Device:STM32Cube HAL:I2C 1.7.4, Device:STM32Cube HAL:IWDG 1.7.4, Device:STM32Cube HAL:NAND 1.7.4, Device:STM32Cube HAL:PWR 1.7.4, Device:STM32Cube HAL:RCC 1.7.4, Device:STM32Cube HAL:RNG 1.7.4, Device:STM32Cube HAL:RTC 1.7.4, Device:STM32Cube HAL:SD 1.7.4, Device:STM32Cube HAL:SPI 1.7.4, Device:STM32Cube HAL:Smartcard 1.7.4, Device:STM32Cube HAL:TIM 1.7.4, Device:STM32Cube HAL:UART 1.7.4, Device:STM32Cube HAL:USART 1.7.4, Device:STM32Cube HAL:WWDG 1.7.4, Device:Startup 2.6.2
